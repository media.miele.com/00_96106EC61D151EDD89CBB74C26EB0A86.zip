Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-08-24T09:44:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 24 09:44:04 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\77a348be-1e8e-4943-9d6a-3237e4e984f1\ef3a0d7d-d8f6-40b8-ab01-bd8744ae2e7f\ifc * Database version: 5507 * Database creation date: Wed Aug 24 09:44:04 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 24 09:44:04 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 24 09:44:04 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12116050_I_DGC7440HCPro_GRGR:23744038_I_12116050_DGC7440HCPro_GRGR, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel
Type - Pset_BuildingElementProxyCommon - Reference: 23744038_I_12116050_DGC7440HCPro_GRGR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 23744038_I_12116050_DGC7440HCPro_GRGR
Type - Pset_ProvisionForVoid - Depth: 569 mm
Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_GRGR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 456 mm

# IfcDistributionPort, Port_353505
Description: Flow; FlowDirection: SOURCEANDSINK
